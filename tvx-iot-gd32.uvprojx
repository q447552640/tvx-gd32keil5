# Keil uVision project tvx-iot-gd32.uvprojx, settings and files
target tvx-iot-gd32f405rgt6 (6160000::V6.16::ARMCLANG)
  device: GD32F405RG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tvx-iot-gd32 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HXTAL_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./Application/: main.c main.h gd32f4xx.h gd32f4xx_it.c DebugLog.h simcom7670.h
    ./RTE/_tvx-iot-gd32f405rgt6/: RTE_Components.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:ADC 3.0.2, Device:StdPeripherals:CAN 3.0.2, Device:StdPeripherals:CRC 3.0.2, Device:StdPeripherals:CTC 3.0.2, Device:StdPeripherals:DAC 3.0.2, Device:StdPeripherals:DBG 3.0.2, Device:StdPeripherals:DCI 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:ENET 3.0.2, Device:StdPeripherals:EXMC 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:FMC 3.0.2, Device:StdPeripherals:FWDGT 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:I2C 3.0.2, Device:StdPeripherals:IPA 3.0.2, Device:StdPeripherals:IREF 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:RTC 3.0.2, Device:StdPeripherals:SDIO 3.0.2, Device:StdPeripherals:SPI_I2S 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:TLI 3.0.2, Device:StdPeripherals:TRNG 3.0.2, Device:StdPeripherals:USART 3.0.2, Device:StdPeripherals:WWDGT 3.0.2
